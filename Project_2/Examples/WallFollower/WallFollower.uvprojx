# Keil uVision project WallFollower.uvprojx, settings and files
target WallFollower (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LM4F120H5QR Texas Instruments
  pack: Keil.LM4F_DFP.1.0.0
  cpu: IRAM(0x10000000,0x8000) IROM(0x00000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: WallFollower
  c flags: Optim=2 OneElfS=1 v6Lang=1 v6LangP=3 wLevel=3
  c define: rvmdk PART_LM4F120H5QR
  c include: ..;..\..\..
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x10000000 size 0x8000
  group Source
    ./: startup.s ADCSWTrigger.c PLL.c SimpleWallFollower.c
software components: CMSIS:CORE 5.6.0
